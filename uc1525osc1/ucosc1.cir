* /home/ashwini/Downloads/eSim-2.3/library/SubcircuitLibrary/ucosc1/ucosc1.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Sat Jun  1 13:19:41 2024

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q3  Net-_Q2-Pad2_ Net-_Q2-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q5  Net-_Q5-Pad1_ Net-_Q2-Pad1_ Net-_Q2-Pad2_ eSim_PNP
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q9  Net-_Q16-Pad1_ Net-_Q7-Pad1_ Net-_Q10-Pad3_ eSim_PNP
Q10  Net-_Q10-Pad1_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q12  Net-_Q10-Pad2_ Net-_Q10-Pad2_ Net-_Q10-Pad3_ eSim_PNP
Q8  Net-_Q7-Pad1_ Net-_Q5-Pad1_ Net-_I1-Pad2_ eSim_NPN
Q11  Net-_Q10-Pad2_ Net-_Q11-Pad2_ Net-_I1-Pad2_ eSim_NPN
Q13  Net-_Q13-Pad1_ Net-_Q13-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q14  Net-_Q13-Pad1_ Net-_C2-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q15  Net-_Q10-Pad1_ Net-_Q10-Pad1_ Net-_I1-Pad1_ eSim_NPN
Q16  Net-_Q16-Pad1_ Net-_Q10-Pad1_ Net-_I1-Pad1_ eSim_NPN
Q17  Net-_Q10-Pad3_ Net-_C2-Pad1_ Net-_Q17-Pad3_ eSim_NPN
Q1  Net-_C1-Pad2_ Net-_Q1-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q4  Net-_C1-Pad2_ Net-_C1-Pad1_ Net-_Q1-Pad2_ eSim_NPN
Q6  Net-_I1-Pad1_ Net-_Q6-Pad2_ Net-_C1-Pad1_ eSim_PNP
R6  Net-_Q11-Pad2_ Net-_Q13-Pad1_ 2k
R8  Net-_I1-Pad1_ Net-_Q11-Pad2_ 14k
R7  Net-_Q11-Pad2_ Net-_Q10-Pad3_ 7.4k
R9  Net-_C2-Pad2_ Net-_C2-Pad1_ 25k
C2  Net-_C2-Pad1_ Net-_C2-Pad2_ 6p
R10  Net-_Q17-Pad3_ Net-_I1-Pad1_ 3k
I1  Net-_I1-Pad1_ Net-_I1-Pad2_ dc
R3  Net-_C1-Pad1_ Net-_Q6-Pad2_ 23k
C1  Net-_C1-Pad1_ Net-_C1-Pad2_ 5p
R1  Net-_Q1-Pad2_ Net-_I1-Pad1_ 1k
R5  Net-_R5-Pad1_ Net-_Q13-Pad2_ 2k
R2  Net-_Q5-Pad1_ Net-_I1-Pad1_ 1k
R4  Net-_Q6-Pad2_ Net-_I1-Pad1_ 250
U1  Net-_I1-Pad1_ Net-_Q10-Pad3_ Net-_C1-Pad2_ Net-_Q2-Pad1_ Net-_Q5-Pad1_ Net-_R5-Pad1_ Net-_C5-Pad1_ Net-_C6-Pad1_ PORT
Q18  Net-_C4-Pad2_ Net-_C5-Pad2_ Net-_I1-Pad1_ eSim_NPN
Q19  Net-_C5-Pad1_ Net-_C4-Pad1_ Net-_I1-Pad1_ eSim_NPN
R13  Net-_Q10-Pad3_ Net-_C4-Pad2_ 1k
R15  Net-_Q10-Pad3_ Net-_C5-Pad1_ 1k
C4  Net-_C4-Pad1_ Net-_C4-Pad2_ 10n
C5  Net-_C5-Pad1_ Net-_C5-Pad2_ 10n
R12  Net-_Q10-Pad3_ Net-_C4-Pad1_ 100k
R16  Net-_Q10-Pad3_ Net-_C5-Pad2_ 100k
R11  Net-_C4-Pad2_ Net-_C3-Pad2_ 20k
C3  GND Net-_C3-Pad2_ 15n
R14  Net-_C3-Pad2_ Net-_C6-Pad1_ 20k
C6  Net-_C6-Pad1_ GND 15n

.end
